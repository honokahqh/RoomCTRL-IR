# Keil uVision project Project.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARM32F003x6 ARMM0
  pack: ARMM0.ARM32F0xx_DFP.0.0.6
  cpu: CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Target +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XL32F003x6,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\XL32F0xx_HAL_Driver;..\Drivers\CMSIS\Device\XL32F0xx;..\Drivers\BSP\XL32F003xx_Start_Kit;..\Drivers\XL32F0xx_HAL_Driver\Inc;..\Drivers\XL32F0xx_HAL_Driver\Src;..\Drivers\CMSIS\Device\XL32F0xx\Include;..\APP;..\ptos;..\modbus;..\ymodem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ../Drivers/CMSIS/Device/XL32F0xx/Source/: system_xl32f0xx.c
    ../Drivers/CMSIS/Device/XL32F0xx/Source/arm/: startup_xl32f003x6.s
  group Application/User
    ../Src/: main.c xl32f0xx_it.c
    ../APP/: app.c
    ../ymodem/: ymodem.c
  group Doc
    ../: readme.txt
  group BSP\XL32F003xx_Start_Kit
    ../Drivers/BSP/XL32F003xx_Start_Kit/: xl32f003xx_ll_Start_Kit.c
  group Drivers\XL32F0xx_HAL_Driver
    ../Drivers/XL32F0xx_HAL_Driver/Src/: xl32f0xx_ll_exti.c xl32f0xx_ll_gpio.c xl32f0xx_ll_rcc.c xl32f0xx_ll_tim.c xl32f0xx_ll_usart.c xl32f0xx_ll_utils.c
  group APP
    ../APP/: bsp_driver.c flash_driver.c
  group PTOS
    ../ptos/: lc.h lc-addrlabels.h lc-switch.h pt.h pt-sem.h pt-timer.h
  group modbus
    ../modbus/: Modbus_Core.c Modbus_CORE.h Modbus_CRC.c Modbus_CRC.h Modbus_hook.c Modbus_hook.h Modbus_User.c Modbus_USER.h
